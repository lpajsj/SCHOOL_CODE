# Keil uVision project ange_stm32.uvprojx, settings and files
target ange (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ange_stm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,ARM_MATH_CM3
  c include: ..\User;..\MyLibraries\inc;..\Libraries\FWLIB\inc;..\Libraries\CMSIS;..\Libraries\CMSIS\coreinc;..\Hardware\inc;..\DSP\Source\DSP_include;..\DSP\Source\PrivateInclude
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c main.h mainfuzhu.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Mylibrares
    ../MyLibraries/src/: ange_da.c ange_DMA.c ange_exti.c ange_iic.c ange_pwr.c ange_rcc.c ange_rtc_bkp.c ange_spi.c ange_SysTick.c ange_timg.c ange_timj.c ange_timt.c ange_USART.c bsp_led.c ange_wdg.c flash.c ange_flash.c ange_ad.c
  group FWLIB
    ../Libraries/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
    ../Libraries/CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../Libraries/CMSIS/coreinc/: core_cm3.h
  group Hardware
    ../Hardware/src/: AD5410.C ad7799.c AD9910V1.C ADDA.C ads8361.c chuankouping.c key.c pwm.c shumaguan.c USART_HIM.C hanshu.c DDS_API.c
  group Doc
    ../Doc/: 说明.txt
  group DSP
    ../DSP/: arm_cortexM3l_math.lib
    ../DSP/Source/DSP_/: BasicMathFunctions.c BayesFunctions.c CommonTables.c ComplexMathFunctions.c ControllerFunctions.c DistanceFunctions.c FastMathFunctions.c FilteringFunctions.c MatrixFunctions.c StatisticsFunctions.c SupportFunctions.c SVMFunctions.c TransformFunctions.c
target ange_RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: ange_stm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,ARM_MATH_CM3,VECT_TAB_SRAM
  c include: ..\User;..\MyLibraries\inc;..\Libraries\FWLIB\inc;..\Libraries\CMSIS;..\Libraries\CMSIS\coreinc;..\Hardware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\RAM调试.sct
