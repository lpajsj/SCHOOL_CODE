# Keil uVision project MPU6050.uvprojx, settings and files
target MPU6050 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\USMART;..\HARDWARE\ANO;..\HARDWARE\IIC;..\HARDWARE\Modules_MPU6050;..\HARDWARE\Algorithm\Algorithm_filter;..\HARDWARE\Algorithm\Algorithm_math;..\HARDWARE\Algorithm\Algorithm_quaternion;..\HARDWARE\Attitude;..\HARDWARE\SPI;..\HARDWARE\USART;..\HARDWARE\WDG;..\HARDWARE\MultiRotor_systime;..\HARDWARE\TIMER;..\HARDWARE\SST25VF16;..\SYSTEM\CRC;..\HARDWARE\STM32Flash;..\HARDWARE\TLC2543;..\HARDWARE\RTC;..\HARDWARE\exit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h
  group HARDWARE
    ../HARDWARE/Attitude/: attitude.c
    ../HARDWARE/Algorithm/Algorithm_filter/: Algorithm_filter.c
    ../HARDWARE/Algorithm/Algorithm_math/: Algorithm_math.c
    ../HARDWARE/Algorithm/Algorithm_quaternion/: Algorithm_quaternion.c
    ../HARDWARE/SST25VF16/: Flash.c
    ../HARDWARE/IIC/: I2C.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Modules_MPU6050/: MPU6050.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/STM32Flash/: stm32_flash.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/MultiRotor_systime/: MultiRotor_systime.C
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TLC2543/: tlc2543.c
    ../HARDWARE/exit/: exit.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/CRC/: check.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_sdio.c
  group DOC
    ../DOC/: README.TXT
