# Keil uVision project angeku.uvprojx, settings and files
target ange (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: angeku
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: define STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\fwlib\inc;..\User;..\mylibraries\RCC;..\mylibraries\led;..\mylibraries\exti;..\Libraries\CMSIS\coreinc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group cmsis
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h system_stm32f10x.h
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group user
    ../User/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h main.c
    ../mylibraries/exti/: ange_exti.c
    ../mylibraries/led/: bsp_led.c
    ../mylibraries/RCC/: ange_rcc.c
  group doc
    ../doc/: mainfuzhu.c
  group fwlib
    ../Libraries/fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
