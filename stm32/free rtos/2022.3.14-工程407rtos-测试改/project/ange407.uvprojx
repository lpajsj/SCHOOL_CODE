# Keil uVision project ange407.uvprojx, settings and files
target ange (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ange407
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\coreinc;..\Libraries\fwlib\inc;..\User;..\mylibraries\inc;..\myhardware\inc;..\DMP_empl;..\freertos\include;..\freertos\portable\RVDS\ARM_CM4F;..\freertos\CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group mylibrary
    ../mylibraries/src/: ange_SysTick.c ange_USART.c ange_rcc.c ange_exti.c ange_DMA.c ange_ad.c ange_timj.c ange_timt.c ange_timg.c ange_da.c ange_spi.c bsp_led.c ange_iic_24c02.c ange_iic.c ange_iic_2.c
  group fwlib
    ../Libraries/fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group hardware
    ../myhardware/src/: MS5611.c MPU6050.c MPU6050_2.c QMC5883.c icm20689.c OLED2.c lcd.c
  group CMSIS
    ../Libraries/CMSIS/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
    ../Libraries/CMSIS/coreinc/: core_cm4.h
    ../Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group doc
    ../doc/: mainfuzhu.c 说明.txt
  group DMP_empl
    ../DMP_empl/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group rtos_code
    ../freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c malloc.c timer.c
    ../freertos/portable/RVDS/ARM_CM4F/: port.c
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/CMSIS_RTOS/: cmsis_os.c
