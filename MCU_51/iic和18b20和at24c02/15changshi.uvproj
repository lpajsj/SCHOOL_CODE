# Keil uVision project 15changshi.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 15changshi +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\公共文件
  group Source Group 1
    ./: STARTUP.A51 changshi.c
    ../公共文件/: 15.c ange.c iic.c onewire.c
